# IAR project WL9F_Monitor_APP.ewp, settings and files
configuration STM324xG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\Platform\COMMON\INC; ..\Platform\TaeHa - ECS\INC; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WLF_Monitor_APP.hex
  ILINK.IlinkOutputFile: WL9F_Monitor_APP.out
  ILINK.IlinkIcfFile: LinkerConfiguration\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS/INC
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group Platform/COMMON/INC
    ../Platform/COMMON/INC/: endecoder.h main.h stm324xg_eval.h stm32_eval_legacy.h stm32f4xx_conf.h stm32f4xx_it.h
  group Platform/COMMON/SRC
    ../Platform/COMMON/SRC/: endecoder.o main.c stm324xg_eval.c stm32f4xx_it.c system_stm32f4xx.c
  group Platform/TaeHa - ECS/INC
    ../Platform/TaeHa - ECS/INC/: Buzzer.h CAN_Control.h DPRAM_Control.h FM31X4.h GPIO_Control.h Hardware_Version.h KeySwitch.h LAMP_Control.h LCD_Control.h M25PXX.h RTC.h System_Debug.h System_Init.h TimeDelay.h TW2835_Control.h TW2835_OSD.h TW8816_Control.h TW8816_OSD.h TW8832_Control.h TW8832_OSD.h UART_Control.h WL9F_Monitor_APP.h WL9F_Monitor_Variable.h
  group Platform/TaeHa - ECS/SRC
    ../Platform/TaeHa - ECS/SRC/: Buzzer.c CAN_Control.c DPRAM_Control.c FM31X4.c GPIO_Control.c Hardware_Version.c KeySwitch.c LAMP_Control.c LCD_Control.c M25PXX.c RTC.c System_Debug.c System_Init.c TimeDelay.c TW2835_Control.c TW2835_OSD.c TW8816_Control.c TW8816_OSD.c TW8832_Control.c TW8832_OSD.c UART_Control.c WL9F_Monitor_APP.c
  group STM32F4xx_StdPeriph_Driver/INC
    ../Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group STM32F4xx_StdPeriph_Driver/SRC
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
