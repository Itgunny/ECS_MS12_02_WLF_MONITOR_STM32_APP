<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\WL9F_Monitor_APP.ewp</path>
  </project>
  <batchBuild/>
</workspace>


